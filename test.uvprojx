# Keil uVision project test.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Code
    ./: main.c leds.c buttons.c spi.c isr.c uart.c definitions.h ad9910.c
software components: CMSIS:CORE 5.6.0, CMSIS Driver:SPI 1.11.0, Device:STM32Cube Framework:Classic 1.2.9, Device:STM32Cube HAL:Common 1.2.9, Device:STM32Cube HAL:Cortex 1.2.9, Device:STM32Cube HAL:DMA 1.2.9, Device:STM32Cube HAL:GPIO 1.2.9, Device:STM32Cube HAL:PWR 1.2.9, Device:STM32Cube HAL:RCC 1.2.9, Device:STM32Cube HAL:SPI 1.2.9, Device:STM32Cube HAL:TIM 1.2.9, Device:STM32Cube HAL:UART 1.2.9, Device:Startup 1.2.5
